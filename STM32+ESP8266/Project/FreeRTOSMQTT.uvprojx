# Keil uVision project FreeRTOSMQTT.uvprojx, settings and files
target MQTT (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PriceTag +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\FreeRTOS\inc;..\Source;..\Source\Usb\Mass_Storage\inc;..\Source\Usb\STM32_USB-FS-Device_Driver\inc;..\Source\FATFS;..\Source\bsp;..\Source\esp8266;..\Source\app;..\Source\MQTTPacket\src;..\Source\MQTTPacket;..\Source\DHT11;..\Source\sys;..\Source\delay;..\Source\OLED;..\Source\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
    ../FreeRTOS/inc/: FreeRTOSConfig.h
  group BSP
    ../Source/bsp/: bsp_config.h bsp.h bsp.c
    ../Source/bsp/usart/: bsp_usart1.c
    ../Source/bsp/printf/: bsp_printf.c
    ../Source/bsp/key/: bsp_key_exti.c
    ../Source/bsp/led/: bsp_led.c
    ../Source/bsp/gpio/: bsp_gpio.c bsp_gpio.h
    ../Source/bsp/dwt/: bsp_dwt.c
    ../Source/bsp/iic/: bsp_iic.c
    ../Source/bsp/sht20/: bsp_sht20.c
    ../Source/bsp/delay/: bsp_delay.c
    ../Source/OLED/: oled.c
    ../Source/ADC/: adc.c
  group ESP8266
    ../Source/esp8266/: esp8266_init.c esp8266_handler.c
  group MQTT
    ../Source/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../Source/MQTTPacket/samples/: pub0sub1.c transport.c
    ../Source/MQTTPacket/: mqtt.h
  group USER
    ../Source/: main.h main.c stm32f10x_it.c
    ../Source/app/: app_config.h
    ../Source/DHT11/: dht11.c
    ../Source/sys/: sys.c
    ../Source/delay/: delay.c
